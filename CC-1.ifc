Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 24bfaa4f-541c-4f90-8074-342e95d23307, NumberOfSaves: 58], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2025-12-12T10:22:45+07:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 4

# IfcBuildingStorey: Level:ISL_Level Name & Elevation - End 2 - Project (15)
In: Building Name
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
u/s GRADEBEAM | u/s GRADEBEAM | 8950
MAIN FLOOR | MAIN FLOOR | 10000
T/O STAGE | T/O STAGE | 11200
U/S DAYCARE ROOF | U/S DAYCARE ROOF | 13448
U/S SECOND FLOOR | U/S SECOND FLOOR | 13893
MEZZANINE | MEZZANINE | 14000
SECOND FLOOR | SECOND FLOOR | 14100
DAYCARE PARAPET | DAYCARE PARAPET | 14900
LOWER PARAPET | LOWER PARAPET | 15400
U/S THIRD FLOOR | U/S THIRD FLOOR | 17993
THIRD FLOOR | THIRD FLOOR | 18200
U/S GYM DECK | U/S GYM DECK | 18500
THIRD FLOOR PARAPET | THIRD FLOOR PARAPET | 19200
u/s ROOF DECK | u/s ROOF DECK | 22300
HIGHER PARAPET | HIGHER PARAPET | 23100

# IfcBeam: M_Round Bars:RB12.7 (2)
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Metal - Steel - 345 MPa
Pset_BeamCommon - Reference: RB12.7; Span: 260 mm; Slope: 0 deg
Pset_QuantityTakeOff - Reference: RB12.7; sets with these values: 2
Name (M_Round Bars:RB12.7:...)
2253692
2463895

# IfcBuildingElementProxy: 01. THREADED ROD - 3D:A325 1/2"Ø BOLT (4)
Type - Material: Metal - Steel - 345 MPa
Pset_BuildingElementProxyCommon - Reference: A325 1/2"Ø BOLT; sets with these values: 2
Name (01. THREADED ROD - 3D:A325 1/2"Ø BOLT:...) | In
2252931 | U/S SECOND FLOOR
2253015 | T/O STAGE
2253039 | T/O STAGE
2253041 | T/O STAGE

# IfcBuildingElementProxy: CSK SCREW 8mm_with_Void:8-160/143_90° (8)
In: U/S SECOND FLOOR
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-160/143_90°; sets with these values: 2
Name (CSK SCREW 8mm_with_Void:8-160/143_90°:...)
2247548
2247549
2247550
2247551
2253228
2253229
2253230
2253231

# IfcBuildingElementProxy: Non shink grout:10mm, Non shink grout:10mm:2248935
In: U/S SECOND FLOOR
Type - Material: Default
Pset_BuildingElementProxyCommon - Reference: 10mm; sets with these values: 2

# IfcBuildingElementProxy: SK SCREW 6mm:6-80/50 (16)
In: U/S DAYCARE ROOF
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 6-80/50; sets with these values: 2
Name (SK SCREW 6mm:6-80/50:...)
2445769
2445787
2460084
2460086
2460095
2460097
2460108
2460110
2460119
2460121
2460138
2460140
2460583
2460585
2464659
2464660

# IfcBuildingElementProxy: Structural Connections 16:Structural Connections 1, Structural Connections 16:Structural Connections 1:2464155
In: U/S SECOND FLOOR
Type - Material: Metal - Steel - 345 MPa
Pset_BuildingElementProxyCommon - Reference: Structural Connections 1; sets with these values: 2

# IfcBuildingElementProxy: Structural Connections 7:Structural Connections 1, Structural Connections 7:Structural Connections 1:2247547
In: SECOND FLOOR
Type - Material: Metal - Steel - 345 MPa
Pset_BuildingElementProxyCommon - Reference: Structural Connections 1; sets with these values: 2

# IfcBuildingElementProxy: Structural Connections 8:Structural Connections 1, Structural Connections 8:Structural Connections 1:2249020
In: U/S DAYCARE ROOF
Type - Material: Metal - Steel - 345 MPa
Pset_BuildingElementProxyCommon - Reference: Structural Connections 1; sets with these values: 2

# IfcBuildingElementProxy: Structural Connections 9:Structural Connections 1, Structural Connections 9:Structural Connections 1:2253211
In: U/S DAYCARE ROOF
Type - Material: Metal - Steel - 345 MPa
Pset_BuildingElementProxyCommon - Reference: Structural Connections 1; sets with these values: 2

# IfcColumn: M_Concrete-Rectangular-Column1:PL-8, M_Concrete-Rectangular-Column1:PL-8:542090
In: U/S SECOND FLOOR
Type - PredefinedType: COLUMN; Material: Concrete, Cast-in-Place gray
Type - Pset_ColumnCommon - IsExternal: no; LoadBearing: yes
Pset_ColumnCommon - Reference: PL-8
Pset_QuantityTakeOff - Reference: PL-8; sets with these values: 2

# IfcColumn: M_Glulam-Southern Pine-Column:315x304 (3)
In: U/S SECOND FLOOR
Type - PredefinedType: COLUMN; Material: _Timber_ISL
Type - Pset_ColumnCommon - IsExternal: no; LoadBearing: yes
Pset_ColumnCommon - Reference: 315x304
Pset_QuantityTakeOff - Reference: 315x304; sets with these values: 2
Name (M_Glulam-Southern Pine-Column:315x304:...)
725552
2253071
2253072

# IfcColumn: M_HSS Square-Column:HSS101.6X101.6X4.8 (2)
In: U/S SECOND FLOOR
Type - PredefinedType: COLUMN; Material: Metal - Steel - 345 MPa
Type - Pset_ColumnCommon - IsExternal: no; LoadBearing: yes
Pset_ColumnCommon - Reference: HSS101.6X101.6X4.8
Pset_QuantityTakeOff - Reference: HSS101.6X101.6X4.8; sets with these values: 2
Name (M_HSS Square-Column:HSS101.6X101.6X4.8:...)
2247591
2253220

# IfcColumn: M_HSS Square-Column:HSS152.4X152.4X6.4, M_HSS Square-Column:HSS152.4X152.4X6.4:2253055
In: U/S DAYCARE ROOF
Type - PredefinedType: COLUMN; Material: Metal - Steel - 345 MPa
Type - Pset_ColumnCommon - IsExternal: no; LoadBearing: yes
Pset_ColumnCommon - Reference: HSS152.4X152.4X6.4
Pset_QuantityTakeOff - Reference: HSS152.4X152.4X6.4; sets with these values: 2
