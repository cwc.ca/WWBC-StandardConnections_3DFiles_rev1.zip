Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 24bfaa4f-541c-4f90-8074-342e95d23307, NumberOfSaves: 58], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2025-12-12T10:20:34+07:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 4

# IfcBuildingStorey: Level:ISL_Level Name & Elevation - End 2 - Project (15)
In: Building Name
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
u/s GRADEBEAM | u/s GRADEBEAM | 8950
MAIN FLOOR | MAIN FLOOR | 10000
T/O STAGE | T/O STAGE | 11200
U/S DAYCARE ROOF | U/S DAYCARE ROOF | 13448
U/S SECOND FLOOR | U/S SECOND FLOOR | 13893
MEZZANINE | MEZZANINE | 14000
SECOND FLOOR | SECOND FLOOR | 14100
DAYCARE PARAPET | DAYCARE PARAPET | 14900
LOWER PARAPET | LOWER PARAPET | 15400
U/S THIRD FLOOR | U/S THIRD FLOOR | 17993
THIRD FLOOR | THIRD FLOOR | 18200
U/S GYM DECK | U/S GYM DECK | 18500
THIRD FLOOR PARAPET | THIRD FLOOR PARAPET | 19200
u/s ROOF DECK | u/s ROOF DECK | 22300
HIGHER PARAPET | HIGHER PARAPET | 23100

# IfcBeam: ISL_Heavy Timber:265x532, ISL_Heavy Timber:265x532:2435816
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Wood - GLULAM
Pset_BeamCommon - Slope: 0 deg; Reference: 265x532; Span: 1200 mm
Pset_QuantityTakeOff - Reference: 265x532; sets with these values: 2

# IfcBeam: ISL_Heavy Timber:265x646, ISL_Heavy Timber:265x646:2192307
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Wood - GLULAM
Pset_BeamCommon - Reference: 265x646; Span: 1700 mm; Slope: 0 deg
Pset_QuantityTakeOff - Reference: 265x646; sets with these values: 2

# IfcBuildingElementProxy: 200x80_16_Scr:Standard (2)
In: U/S SECOND FLOOR
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Name (200x80_16_Scr:Standard:...)
2196222
2235470

# IfcBuildingElementProxy: CYL SCREW 8mm:8-180/164 (2)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-180/164; sets with these values: 2
Name (CYL SCREW 8mm:8-180/164:...) | In
2218122 | MAIN FLOOR
2259201 | T/O STAGE

# IfcBuildingElementProxy: CYL SCREW 8mm:8-300/284 (2)
In: MEZZANINE
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-300/284; sets with these values: 2
Name (CYL SCREW 8mm:8-300/284:...)
2217737
2258860

# IfcBuildingElementProxy: CYL SCREW 8mm:8-430/414 (2)
In: MEZZANINE
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-430/414; sets with these values: 2
Name (CYL SCREW 8mm:8-430/414:...)
2217626
2259199
