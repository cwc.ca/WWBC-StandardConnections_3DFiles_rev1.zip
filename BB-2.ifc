Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 24bfaa4f-541c-4f90-8074-342e95d23307, NumberOfSaves: 58], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2025-12-12T10:21:02+07:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey: Level:ISL_Level Name & Elevation - End 2 - Project (15)
In: Building Name
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
u/s GRADEBEAM | u/s GRADEBEAM | 8950
MAIN FLOOR | MAIN FLOOR | 10000
T/O STAGE | T/O STAGE | 11200
U/S DAYCARE ROOF | U/S DAYCARE ROOF | 13448
U/S SECOND FLOOR | U/S SECOND FLOOR | 13893
MEZZANINE | MEZZANINE | 14000
SECOND FLOOR | SECOND FLOOR | 14100
DAYCARE PARAPET | DAYCARE PARAPET | 14900
LOWER PARAPET | LOWER PARAPET | 15400
U/S THIRD FLOOR | U/S THIRD FLOOR | 17993
THIRD FLOOR | THIRD FLOOR | 18200
U/S GYM DECK | U/S GYM DECK | 18500
THIRD FLOOR PARAPET | THIRD FLOOR PARAPET | 19200
u/s ROOF DECK | u/s ROOF DECK | 22300
HIGHER PARAPET | HIGHER PARAPET | 23100

# IfcBeam: ISL_Heavy Timber:130x304 (2)
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Wood - GLULAM
Pset_BeamCommon - Reference: 130x304; Span: 1121.74 mm; Slope: 4.08968 deg
Pset_QuantityTakeOff - Reference: 130x304; sets with these values: 2
Name (ISL_Heavy Timber:130x304:...)
2228305
2228307

# IfcBeam: ISL_Heavy Timber:265x646, ISL_Heavy Timber:265x646:2228306
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Wood - GLULAM
Pset_BeamCommon - Reference: 265x646; Span: 1740 mm; Slope: 0 deg
Pset_QuantityTakeOff - Reference: 265x646; sets with these values: 2

# IfcBuildingElementProxy: CSK SCREW 8mm_with_Void:CSK_8-140/123_45° (3)
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: CSK_8-140/123_45°; sets with these values: 2
Name (CSK SCREW 8mm_with_Void:CSK_8-140/123_45°:...) | In
2228311 | U/S DAYCARE ROOF
2228313 | U/S SECOND FLOOR
2232430 | U/S SECOND FLOOR

# IfcBuildingElementProxy: CYL SCREW 8mm:8-140/144 (2)
In: MEZZANINE
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-140/144; sets with these values: 2
Name (CYL SCREW 8mm:8-140/144:...)
2232307
2232784

# IfcBuildingElementProxy: C_A34_3d_Cad_MULT_Prod:C_A34_3d_Cad_MULT_Prod (2)
In: MEZZANINE
Type - Material: Galvanized
Type - Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie Company Inc.
Pset_BuildingElementProxyCommon - Reference: C_A34_3d_Cad_MULT_Prod; sets with these values: 2
Name (C_A34_3d_Cad_MULT_Prod:C_A34_3d_Cad_MULT_Prod:...)
2228309
2228310

# IfcBuildingElementProxy: F_SD9112_3d_Cad_MULT_Prod:F_SD9112_3d_Cad_MULT_Prod (16)
In: MEZZANINE
Type - Material: Galvanized
Type - Pset_ManufacturerTypeInformation - Manufacturer: Simpson Strong-Tie Company Inc.
Pset_BuildingElementProxyCommon - Reference: F_SD9112_3d_Cad_MULT_Prod; sets with these values: 2
Name (F_SD9112_3d_Cad_MULT_Prod:F_SD9112_3d_Cad_MULT_Prod:...)
2229542
2229559
2229567
2229579
2231663
2231700
2231706
2232128
2232206
2232207
2232208
2232209
2232211
2232212
2232213
2232214
