Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [VersionGUID: 13d8fad5-ffe0-4e57-8c15-73b773531edd, NumberOfSaves: 61], CoordinateReference [CoordinateBase: Shared Coordinates, ProjectSite: Internal]
File name: Project Number
Time: 2025-12-15T08:52:35+07:00
Written by: ODA SDAI 24.6
Made in: Autodesk Revit 24.2.10.64 (ENG) - IFC 24.2.10.64

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 401672; RefLongitude: -71, -3, -24, -345703; RefElevation: 0 mm

# IfcBuilding, Building Name
LongName: Building Name
Pset_BuildingCommon - NumberOfStoreys: 3

# IfcBuildingStorey: Level:ISL_Level Name & Elevation - End 2 - Project (15)
In: Building Name
Pset_AirSideSystemInformation - sets with these values: 2
Name | LongName = Name | Elevation (mm)
u/s GRADEBEAM | u/s GRADEBEAM | 8950
MAIN FLOOR | MAIN FLOOR | 10000
T/O STAGE | T/O STAGE | 11200
U/S DAYCARE ROOF | U/S DAYCARE ROOF | 13448
U/S SECOND FLOOR | U/S SECOND FLOOR | 13893
MEZZANINE | MEZZANINE | 14000
SECOND FLOOR | SECOND FLOOR | 14100
DAYCARE PARAPET | DAYCARE PARAPET | 14900
LOWER PARAPET | LOWER PARAPET | 15400
U/S THIRD FLOOR | U/S THIRD FLOOR | 17993
THIRD FLOOR | THIRD FLOOR | 18200
U/S GYM DECK | U/S GYM DECK | 18500
THIRD FLOOR PARAPET | THIRD FLOOR PARAPET | 19200
u/s ROOF DECK | u/s ROOF DECK | 22300
HIGHER PARAPET | HIGHER PARAPET | 23100

# IfcBeam: ISL_Heavy Timber:265x532, ISL_Heavy Timber:265x532:2437780
In: U/S SECOND FLOOR
Type - Pset_BeamCommon - IsExternal: no; LoadBearing: yes
Classification: B10 Uniformat (Uniformat); Material: Wood - GLULAM
Pset_BeamCommon - Reference: 265x532; Span: 1200 mm; Slope: 0 deg
Pset_QuantityTakeOff - Reference: 265x532; sets with these values: 2

# IfcBuildingElementProxy: 200x80_16_Scr:Standard (2)
In: U/S SECOND FLOOR
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: Standard; sets with these values: 2
Name (200x80_16_Scr:Standard:...)
2233435
2234133

# IfcBuildingElementProxy: CYL SCREW 8mm:8-180/164 (2)
In: T/O STAGE
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-180/164; sets with these values: 2
Name (CYL SCREW 8mm:8-180/164:...)
2233339
2301829

# IfcBuildingElementProxy: CYL SCREW 8mm:8-300/284 (2)
In: MEZZANINE
Type - Material: <Unnamed>
Pset_BuildingElementProxyCommon - Reference: 8-300/284; sets with these values: 2
Name (CYL SCREW 8mm:8-300/284:...)
2233338
2301828

# IfcColumn: M_Glulam-Southern Pine-Column:315x304 (2)
In: U/S SECOND FLOOR
Type - PredefinedType: COLUMN; Material: _Timber_ISL
Type - Pset_ColumnCommon - IsExternal: no; LoadBearing: yes
Pset_ColumnCommon - Reference: 315x304
Pset_QuantityTakeOff - Reference: 315x304; sets with these values: 2
Name (M_Glulam-Southern Pine-Column:315x304:...)
2233342
2507589
